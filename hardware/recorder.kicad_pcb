# Repository akiihito/expresslrs_realtime_recorder

File README.md:

# ExpressLRS Realtime Recorder

USBゲームパッドをExpressLRS送信機として使用するアダプター。
Raspberry Pi PicoでゲームパッドのUSB HID入力を取得し、CRSFプロトコルに変換してExpressLRS送信モジュールに送信する。

## システム構成

```
USBゲームパッド
    ↓ USB Host (HID, micro-USB)
Raspberry Pi Pico
    ├→ GP0 UART0 TX (CRSF 921.6kbps 反転 半二重) → BetaFPV Nano TX Module V2 → ExpressLRS → BetaFPV Pavo Pico II
    └→ GP4/5 UART1 (921600bps) → USB-シリアル変換 → PC (デバッグ/値確認・ログ記録)
```

操作を Pico 内蔵フラッシュに記録し、再生できる（GP2ボタンでモード切替、ゲームパッドのLBで記録start/stop）。
詳細は「動作モード」参照。入力デバイスの癖に合わせた**入力プロファイル**（GP6で切替）も持つ。

> 詳細な仕様・設計判断の経緯は [`CLAUDE.md`](CLAUDE.md)、操作一覧の印刷用シートは
> [`docs/controls.html`](docs/controls.html) にある。

## ハードウェア

| コンポーネント | 説明 |
|---------------|------|
| Raspberry Pi Pico | メインマイコン |
| Logitech F310 | 入力デバイス（**裏スイッチをDモードに**）。汎用HIDパッドも可 |
| BetaFPV LiteRadio 3 | 入力デバイス（プロポ。GP6でLITERADIOプロファイルに切替） |
| BetaFPV Nano TX Module V2 | ExpressLRS送信モジュール |
| BetaFPV Pavo Pico II | 機体（F4 2-3S 20A AIO FC, Serial ELRS 2.4G受信機内蔵） |

## ピン配置

| Pico Pin | 接続先 | 説明 |
|----------|--------|------|
| USB (micro-USB) | ゲームパッド | USB Host |
| GP0 (UART0 TX) | Nano TX | CRSF出力 (921.6kbps 反転 半二重) |
| GP1 (UART0 RX) | Nano TX | 半二重テレメトリ受信 |
| GP4 (UART1 TX) | USB-シリアル変換 → PC | デバッグ出力 (921600bps) |
| GP5 (UART1 RX) | USB-シリアル変換 → PC | デバッグ入力（コマンド） |
| GP2 | タクトSW → GND | モード切替ボタン（内部プルアップ） |
| GP6 | タクトSW → GND | 入力プロファイル切替ボタン |
| GP10 / GP11 / GP12 | LED(100Ω) → GND | モードLED 赤=記録 / 緑=再生 / 青=単純 |
| GP13 / GP14 | LED(100Ω) → GND | 入力プロファイルLED 汎用 / LiteRadio |
| VBUS (pin40) | 降圧モジュール出力 5V | Pico＋ゲームパッドの給電（**VSYSではない**） |
| GND (pin3) | 共通GND | LiPo−を起点にスター結線 |
| 内蔵LED | - | 状態表示（接続:点灯 / 未接続:点滅 / 再生モード:速点滅） |

LEDの直列抵抗は**実機で100Ω**（緑/青はVf≈3Vあり330Ωでは暗い）。GP3はArmスイッチ用に予約。
**GP15(pin20)は本個体にヘッダ未実装のため使用不可**。
Nano TX Module は 5V では動かないので **LiPo(7〜13V)をVBATへ直結**する。
電源・配線の詳細とスター結線は [`CLAUDE.md`](CLAUDE.md) 参照。

## ビルド

### 必要環境

- [Pico SDK](https://github.com/raspberrypi/pico-sdk)（tinyusb サブモジュール込み）
- CMake 3.13以上
- **ARM GNU Toolchain の公式 tar.xz 版**。⚠️ Homebrew formula の `arm-none-eabi-gcc` は
  newlib(`nosys.specs`) を持たず**リンクに失敗する**ので使わない。

### SDKへのパッチ適用（初回・SDK入れ直し時に1回）

```bash
export PICO_SDK_PATH=/path/to/pico-sdk
./scripts/apply_sdk_patch.sh
```

⚠️ **これを忘れると Logitech F310 が HID レポートを1本も返さない**（列挙とHIDマウントまでは
成功するので原因が分かりにくい）。F310が最初の転送を DATA1 PID で始めるのに対し、RP2040 は
データシーケンスエラーから回復できないチップバグ（TinyUSB issue #2776）があるため。
SDK は git 管理外なので、入れ直すと失われる。冪等なので何度実行してもよい。

### Picoファームウェアのビルド

```bash
export PICO_SDK_PATH=/path/to/pico-sdk
export PICO_TOOLCHAIN_PATH=/path/to/gcc-arm-none-eabi
mkdir build && cd build
cmake ..
make -j$(sysctl -n hw.ncpu)   # Linux なら $(nproc)
```

⚠️ `build/` で cmake を再実行するときは `PICO_SDK_PATH` と `PICO_TOOLCHAIN_PATH` を
**両方渡すこと**（キャッシュを消すと環境が失われる）。

### テストのビルド・実行

```bash
mkdir build_test && cd build_test
cmake -DBUILD_TESTS=ON ..
make -j$(sysctl -n hw.ncpu)
ctest --output-on-failure
```

ドキュメントがコードから古くなっていないかの機械チェック（UARTコマンド・GPIO番号・
調整パラメータの網羅）も合わせて走らせる。詳細と限界は [`CLAUDE.md`](CLAUDE.md) の「開発ルール」。

```bash
python3 scripts/check_docs.py
```

ホスト側でリンクが `tapi error: malformed file` / `unknown architecture` で失敗する場合は、
CommandLineTools の SDK が Xcode の `ld` より新しいのが原因。
`-DCMAKE_OSX_SYSROOT=$(xcode-select -p)/Platforms/MacOSX.platform/Developer/SDKs/MacOSX.sdk`
を付けて configure すれば通る（恒久対応はXcodeの更新）。

## 書き込み

1. PicoのBOOTSELボタンを押しながらUSB接続
2. `RPI-RP2`としてマウントされることを確認
3. 書き込みスクリプトを実行:

```bash
./scripts/flash.sh
```

または手動で:

```bash
cp build/expresslrs_realtime_recorder.uf2 /Volumes/RPI-RP2/
```

## シリアルモニター

micro-USB はゲームパッド専有なので、PCログは **UART1(GP4/5) + USB-シリアル変換**で取る。

```bash
./scripts/monitor.sh            # デフォルト 921600bps
./scripts/monitor.sh 115200     # ⚠️ 手元のFTDI変換器は分周器バグで8倍ずれるのでこちら
```

終了: `Ctrl+A`, `K`, `y`（`Ctrl+A`→`D` はデタッチでポートを掴んだままになる）

| キー | 動作 |
|---|---|
| `?` | ヘルプ。1行目に**現在のモード・入力プロファイル・フラッシュのログ数** |
| `d` | スナップショット（生HID → state → CRSF → フレーム → CRC を全段ダンプ） |
| `s` | 連続ストリーム ON/OFF（25Hz CSV、`live_view.py` 用）※トグル |
| `r` | 記録 start/stop（RECORD時のみ。ゲームパッドのLBと同じ） |
| `p` | 再生 start/stop（PLAYBACK時のみ） |
| `i` | 入力プロファイル切替（GP6ボタンと同じ） |
| `t` | スロットル/舵の現在設定と各スティック位置での出力を表示 |
| `[` `]` | ホバリング推力 −/+ 1% |
| `,` `.` | スロットルのエクスポ 弱/強 |
| `5` `6` | 上昇方向の可動幅 −/+ 5%（上に倒した時の加速が強すぎる時は `5`） |
| `7` `8` | 舵角スケール −/+ 5% |
| `9` `0` | 舵のエクスポ 弱/強 5% |

チューニング値は**電源を切ると既定値に戻る**。良い値が出たらソースの `*_DEFAULT_PCT` に焼き直す。

1秒ごとのハートビートの先頭にも現在の状態が出る（`SIMPLE` / `REC-idle` / `REC-ON` /
`REC-FULL` / `PLAY-idle` / `PLAY-ON`）。LEDと同じ情報だが、ログを見返す時に必要になる。

```
[REC-ON   ][CONN] CH1-4:  992  992  499  992 | BTN: 0x0010
```

リアルタイムのバーゲージ表示:

```bash
python3 scripts/live_view.py    # 要 pip install pyserial
```

## 動作モード（単純 / 記録 / 再生）

GP2ボタンで3モードを循環し、GP10-12のLEDで表示する。起動時は安全な**単純(SIMPLE)**。

| モード | LED | 動作 |
|--------|-----|------|
| SIMPLE (単純) | GP12 青 点灯 | ゲームパッド → CRSF パススルー |
| RECORD (記録) | GP10 赤 | パススルー＋**LBで指定した区間**を記録（50Hz, RAM→フラッシュ） |
| PLAYBACK (再生) | GP11 緑 | フラッシュのログを CRSF として再送出 |

- **GP2 短押し**: モード循環 / **GP2 長押し(0.6秒)**: PLAYBACK中に再生 start/stop
- **記録はRECORDに入っただけでは始まらない**。ゲームパッドの **LB**（またはUART `r`）で
  start/stop する。開始のたびにバッファはクリア＝「最後に開始した所からの記録」。
  - 赤LED: **ゆっくり点滅**=待機 / **点灯**=記録中 / **速い点滅**=バッファ満杯(120秒)
- フラッシュへの書出しは**RECORDを抜けた時**に一括（飛行中に書くとXIPが止まり500Hz送信が
  破綻するため）。LBを一度も押さずに通過した時は書かず、保存済みログを残す。
- 再生は PLAYBACK 入場では自動開始しない。長押し or `p` で開始、末尾で自動停止。
  - 緑LED: **点灯**=待機 / **点滅**=再生中（ボタンを受け付けた合図）
- 切断時はスロットル最小＋Arm解除のフェイルセーフを送出（Armトグルのラッチもリセット）。

### 入力プロファイル（GP6で切替、LEDはGP13/GP14）

| プロファイル | スロットル(CH3)の扱い |
|---|---|
| GENERIC (汎用パッド) | **位置型・中央=ホバリング推力**。下端=最小/上端=ホバリング+15%。手を離すとホバリングに戻る |
| LITERADIO (LiteRadio 3) | **絶対値**。ジンバル位置をそのままスロットルに |

GENERIC ではスティックのストロークが実機プロポより遥かに短いため、ロール/ピッチ/ヨーに
**エクスポと舵角スケール**を掛けて鋭さを落としている。D-pad上下でホバリング推力を±1%トリムできる
（電圧降下で沈み始めた時用）。⚠️ **LiteRadio 3 を使う時は必ずLITERADIOに切り替える**
（GENERICのままだと軸がバラバラになる）。

## 配線・プロトタイプ

- [`hardware/`](hardware/) — KiCad 9 プロジェクト（回路図ERC・基板DRCクリーン、105×85mm 2層）。
  KiCad無しで見るなら `hardware/recorder.pdf`（回路図）/ `hardware/pcb-fab.pdf`（基板1:1）。
  ⚠️ **未発注・未検証**。部品表と発注前チェックは [`hardware/README.md`](hardware/README.md)。
- [`docs/perfboard.html`](docs/perfboard.html) — ユニバーサル基板版の配置＆配線リスト（PCB発注前に手組みする用）。
- [`docs/breadboard-bringup.md`](docs/breadboard-bringup.md) — 段階的ブリングアップ手順（Stage A〜F）と実施記録
- [`docs/hardware-validation.md`](docs/hardware-validation.md) — 単票チェックリスト（上の各Stageから参照）
- [`docs/controls.html`](docs/controls.html) — 操作一覧（印刷用）

## プロジェクト構造

```
expresslrs_realtime_recorder/
├── CMakeLists.txt
├── README.md
├── CLAUDE.md                    # プロジェクト仕様書
├── include/
│   ├── crsf.h                   # CRSFプロトコル定義
│   ├── usb_gamepad.h            # ゲームパッドAPI
│   ├── hid_parser.h             # HIDレポートディスクリプタ解析
│   ├── recorder.h               # 記録/再生API
│   └── tusb_config.h            # TinyUSB設定
├── src/
│   ├── main.c                   # メインアプリ（モード/ボタン/LED/マッピング）
│   ├── crsf.c                   # CRSF実装
│   ├── usb_gamepad.c            # USB Host実装
│   ├── hid_parser.c             # ディスクリプタから軸配置を求める
│   └── recorder.c               # 記録/再生（RAM蓄積→フラッシュ）
├── tests/                       # ホストPCで走るユニットテスト(gtest)
│   ├── test_crsf.cpp
│   ├── test_usb_gamepad.cpp
│   ├── test_hid_parser.cpp
│   └── test_recorder.cpp        # 記録ロジック（間引き/ラッチ/再開）
├── scripts/
│   ├── flash.sh                 # 書き込み
│   ├── monitor.sh               # シリアルモニター
│   ├── apply_sdk_patch.sh       # SDKへのF310ワークアラウンド適用
│   ├── check_docs.py            # コードとドキュメントの食い違い検出
│   └── live_view.py             # リアルタイム値ビューア
├── patches/                     # SDKへ当てるパッチ本体
├── docs/                        # ブリングアップ手順・配線図・操作一覧
├── hardware/                    # KiCadプロジェクト（回路図・基板）
├── references/                  # 参照回路図などの資料
└── .claude/
    └── skills/
        ├── build.md             # /build スキル
        └── test.md              # /test スキル
```

## CRSFプロトコル

| 項目 | 値 |
|------|-----|
| ボーレート | 921,600 bps（Nano TX V2 モジュール用。レシーバ直結は420,000） |
| 信号 | 反転UART（Nano TX V2 の S.Port） |
| 通信方式 | 半二重（送信後テレメトリをドレイン） |
| フレームタイプ | 0x16 (RC Channels Packed) |
| チャンネル数 | 16 |
| チャンネル解像度 | 11bit (0-2047) |
| チャンネル値範囲 | 172 (min) - 992 (mid) - 1811 (max) |
| CRC | CRC8-DVB-S2 (多項式 0xD5) |

### パケット構造

```
[SYNC: 0xC8] [LEN: 24] [TYPE: 0x16] [PAYLOAD: 22bytes] [CRC: 1byte]
```

## 対応コントローラー

| デバイス | VID:PID | 状態 |
|---|---|---|
| Logitech F310 | `046D:C216` | **実機確認済み**。裏スイッチを **D** に（Xモードは `046D:C21D` でHIDではない）。SDKパッチ必須 |
| BetaFPV LiteRadio 3 | `0483:572B` | **実機確認済み**。16bit×8ch、AETR順。LITERADIOプロファイルで使う |
| Sony DualShock 4 | `054C:09CC` / `054C:05C4` | 専用パーサーあり（実機未検証） |
| 汎用HIDゲームパッド | — | レポートディスクリプタを解析して軸配置を自動判定 |

## チャンネルマッピング (Mode 2, GENERICプロファイル)

| CRSFチャンネル | ゲームパッド入力 | 備考 |
|---------------|-----------------|------|
| CH1 (Roll) | 右スティック X | エクスポ＋舵角スケール |
| CH2 (Pitch) | 右スティック Y | 反転、エクスポ＋舵角スケール |
| CH3 (Throttle) | 左スティック Y | 反転。**位置型・中央=ホバリング推力**、不感帯＋エクスポ。上側は可動幅を制限（既定15%） |
| CH4 (Yaw) | 左スティック X | エクスポ＋舵角スケール |
| CH5 / CH6 | L2 / R2 トリガー | F310のL2/R2はデジタルなので常に中央値 |
| CH7 (Arm) | Aボタン (Cross) | **押下エッジでトグル**（押しボタンでは保持できないため） |
| CH8 | Bボタン (Circle) | ON/OFF |
| CH9 | Xボタン (Square) | ON/OFF |
| CH10 | Yボタン (Triangle) | ON/OFF |
| CH11 | LBボタン (L1) | ON/OFF。**RECORD中は記録のstart/stopトリガー**（機体側は未使用） |
| CH12 | RBボタン (R1) | ON/OFF |
| CH13-16 | 未使用 | 中央値固定 |
| — | D-pad 上/下 | ホバリング推力を±1%トリム（GENERIC時） |

LITERADIOプロファイルでは送信機がAETRのチャンネル順で軸を並べるため、スティック解釈を挟まず
CH1〜 をそのまま素通しする（スロットルも絶対値）。

> ⚠️ **Armはスロットルスティックを下に押さえたまま行う**。中央がホバリング推力（既定20%≒1200us）
> なので、中央のままだとBetaflightがスロットル高としてArmを拒否する。押さえたままArm →
> ゆっくり離すとホバリングまで上がって離陸、という実機プロポと同じ手順になる。

## 参考資料

- [CRSF Protocol Specification](https://github.com/crsf-wg/crsf/wiki)
- [ExpressLRS CRSF Implementation](https://github.com/ExpressLRS/ExpressLRS/blob/master/src/lib/CrsfProtocol/crsf_protocol.h)
- [TinyUSB Host HID Example](https://github.com/hathach/tinyusb/tree/master/examples/host/hid_controller)
- [Pico SDK Documentation](https://raspberrypi.github.io/pico-sdk-doxygen/)

## ライセンス

MIT License

## KiCad design hardware/recorder.kicad_pcb

File hardware/README.md:

# 回路図 / 基板（KiCad 9）

`recorder.kicad_pro` を KiCad で開く。KiCad無しで見る／印刷する用に
`recorder.pdf`（回路図）と `pcb-fab.pdf`（基板の表面・1:1）。

## 基板の概要

- **105 × 85 mm / 2層 / 全てスルーホール**（初めての基板をハンダ付け1工程で組めるように）
- **裏面は全面GNDベタ**。全部品がスルーホールなのでGNDパッドはベタに直結し、
  GND用の配線もビアも1本も無い。表面の信号配線は**ビア0**。
- Picoの**左列に繋がる部品は左側、右列(VBUS)は右側**に置き、Picoを跨ぐ配線を無くした。
  さらに左側の部品は**Picoのピンと同じY座標**に並べてあるので、配線は水平一直線で
  交差しない。

## 検証状況

| 対象 | 結果 |
|---|---|
| 回路図 ERC | **エラー0 / 警告0** |
| ネットリスト | 全ネットの結線を目視ではなく機械的に突き合わせ済み |
| 基板 DRC | **違反0 / 未配線0**（ゾーン塗りつぶし後） |
| ガーバー出力 | 正常（`kicad-cli pcb export gerbers`） |

生成スクリプトは配線の端点が「同ネットのパッド上」か「同ネットの別配線上」の
どちらかであることを出力前に自己検査する（座標の打ち間違い防止）。

> ⚠️ **実基板は未発注・未検証**。ブレッドボードで動作確認済みの回路を起こしたもので、
> DRCが通っていることと実際に動くことは別。発注前に下記「発注前チェック」を必ず実施。

## ネット一覧（`kicad-cli sch export netlist` の結果）

| ネット | 接続先 |
|---|---|
| `+5V` | J2.3 (Buck OUT+) — U1.40 (VBUS) — C3 — C4 — D6 |
| `VBAT_7_13V` | F1 (ヒューズ出力) — J2.1 (Buck IN+) — J1.3 (Nano TX VBAT) — C1 — C2 |
| （J3.1〜F1） | LiPo+ はヒューズ F1 を通ってから VBAT_7_13V へ |
| `GND` | 全GND（Pico 8本, J1〜J4, SW1〜3, D1〜D5） |
| `CRSF_TX` | U1.1 (GP0) — R6.1 (680Ω) |
| `CRSF_BUS` | R6.2 — J1.1 (Nano TX CRSF) — R7.1 |
| （R7〜GP1） | GP1 は保護抵抗 R7(1kΩ) を介してバスへ |
| `DBG_TX` / `DBG_RX` | U1.6 (GP4) / U1.7 (GP5) — J4.1 / J4.2 |
| `BTN_MODE` | U1.4 (GP2) — SW1 |
| `BTN_INPUT` | U1.9 (GP6) — SW2 |
| `SW_ARM` | U1.5 (GP3) — SW3 |
| `LED_REC` / `LED_PLAY` / `LED_SIMPLE` | U1.14/15/16 (GP10-12) — R1/R2/R3 |
| `LED_GENERIC` / `LED_LITERADIO` | U1.17 (GP13) / U1.19 (GP14) — R4 / R5 |

## ブレッドボードとの違い（要判断）

- **GP1 を CRSF バスに接続している。** ブレッドボードでは GP0 のみ配線して
  Stage D に合格したが、ファームの `crsf_drain_telemetry()` は「半二重で自分の
  送信エコーがRXに入る」前提で書かれており、参照図（63bit氏 R63b）も TXD/RXD を
  1本に結線している。基板ではその形に合わせた。**不要なら J1.1 と GP1 の間を
  切れるようにしておくと安全。**
- **SW3（GP3 の Arm トグルスイッチ）を載せている。** ファーム側の実装は
  commit `1534582` にあるがスイッチ未購入のため revert 中（`eb4c241`）。
  基板には場所を用意しておく方が後で楽なので含めた。

## 部品

PCB版・ユニバーサル基板版で共通（同じ参照記号・同じ部品を使う）。
**寸法とピッチはPCBのフットプリント＝実物の寸法**なので、買う時はこの列を見ること。
「秋月」列は秋月電子通商の販売コード（6桁の新形式。旧 `P-xxxxx` ではない）で、
**2026-10-27 にカタログで確認**した。`—` は秋月に無いもの。

| 参照 | 個数 | 買うもの | 秋月 | 寸法・ピッチ | 備考 |
|---|---|---|---|---|---|
| U1 | 1 | Raspberry Pi Pico（**ヘッダ付きの Pico H** が楽） | — | 2×20 / 2.54mm | メスヘッダに載せる想定（書込み時に外せるように）。USBポートはゲームパッド専有 |
| R1–R5 | 5 | カーボン抵抗 1/4W **100Ω** | `125101` | 軸型・足間10.16mm（2.54mm×4） | LED直列。緑/青はVf≈3Vで330Ωでは暗い。約13mAなので気になれば150Ω。100本袋しか無い |
| R6 | 1 | カーボン抵抗 1/4W **680Ω** | `125681` | 同上 | CRSF半二重バスの保護（衝突時の電流制限） |
| R7 | 1 | カーボン抵抗 1/4W **1kΩ** | `125102` | 同上 | GP1の保護。J1逆挿し時に13Vが直でGPIOへ入るのを防ぐ |
| D1 | 1 | **3mmφ** LED **赤** | `112608` | φ3.0・足2.54mm | RECORD |
| D2 | 1 | **3mmφ** LED **緑** | `111635` | 同上 | PLAYBACK |
| D3 | 1 | **3mmφ** LED **青**（秋月は青緑505nmで代用） | `112719` | 同上 | SIMPLE。⚠️ 3mmの純青は秋月では100個入りしか無い。5mm青でも手組みなら足は2.54mmで入る |
| D4, D5 | 2 | **3mmφ** LED **任意色**（黄を想定） | `111639` | 同上 | 入力プロファイル表示。赤緑青はモード表示で使い切っているので別の色にする |
| D6 | 1 | 双方向TVSダイオード **P6KE6.8CA**／秋月は **P4KE6.8CA**(400W, standoff 5.8V) | `129631` | DO-15軸型・足間10.16mm | 5Vレール。Buck短絡故障・活線挿抜サージ対策。双方向なので極性不問。⚠️ **SMD品(SMAJ5.0CA等)はこの基板に載らない**。型番の数字は降伏電圧なので「5V品」は存在しない（standoffが5.5〜5.8V＝5Vレール用） |
| SW1, SW2 | 2 | **6mm角** 基板用タクトスイッチ（4本足） | `103647` | 6×6mm・足間6.5×4.5mm | モード切替 / 入力切替。内部プルアップ使用。**対角の2本**を使う（同じ側の2本は内部で繋がっている）。⚠️ 足間が2.54mmの倍数でないので、手組みでは7.62×5.08mmに曲げて挿す |
| SW3 | 1 | 基板用 **スライドスイッチ SPST**（1回路2接点） | `115707` | 基板は7.62mm・2端子 | Arm。位置が目視できれば形状は自由（本文では「トグルSW」とも呼んでいる）。**部品待ち**。⚠️ 秋月のSS-12D00G3は3端子2.5mmピッチで**PCBのフットプリントには合わない**（手組みなら中央＋片端の2本を使えば可） |
| J1 | 1 | **JST XHコネクタ 3P**：ベース／ハウジング／コンタクト | `112248`／`112256`／`112264` | 2.5mmピッチ | Nano TX V2（背面視 左から CRSF/GND/7-13V）。**キー付きにする**（逆挿しで最大13VがCRSF線に乗る）。コンタクトは10個入り |
| J2 | 1 | **MP1584EN** 可変降圧モジュール | — | 22.3×16.8mm / 穴間隔18.9mm | **Amazon/AliExpress**（秋月に無い）。穴が2.54mmの倍数でないので手組みではリード線で接続。⚠️ 繋ぐ前に単体で5.0Vに調整 |
| J3 | 1 | LiPo側コネクタ付きピグテール（**XT30**が有力・実機で要確認） | — | 基板は足間7mmの直付けパッド | **ホビーショップ/Amazon**。**送信側（地上側）の電源で、機体に積むパックとは別物**。3Sで確定（2026-10-27）。手持ちのパックとコネクタを揃えれば充電器を共用できる。⚠️ **極性キー付きのものだけ**使う。ネジ端子・素のピンヘッダは不可 |
| J4 | 1 | 2.54mm ピンヘッダ 1×40（切って使う） | `100167` | 2.54mm | USB-シリアル変換（TXD/RXD/GND） |
| F1 | 1 | ヒューズホルダ＋**2A**ヒューズ | 下記参照 | 下記参照 | LiPo+主線。**定格は実測して決める**（2Aは初期値）。⚠️ **遅動(タイムラグ)品が秋月で確認できていない** — 速断型は投入時の突入電流で飛ぶ恐れがある（`107130` は B種とだけ表記）。ホルダの選択肢は下表 |
| C1 | 1 | 電解コンデンサ **470µF/25V** | `117883` | φ10mm・足間5.0mm | Nano TX VBAT直近。送信バーストの電圧ドロップ対策。⚠️ 秋月品はφ8mm/3.5mmピッチなのでPCBでは足を少し広げる |
| C2, C4 | 2 | セラミックコンデンサ **100nF(0.1µF)** | `112670` | φ5mm・足間5.0mm | 高周波側。C2はJ1近く、C4はPicoのVBUS近く。⚠️ 秋月品は2.54mmピッチなのでPCBでは足を広げる |
| C3 | 1 | 電解コンデンサ **100µF/16V** | `105002` | φ6.3mm・足間2.5mm | Pico VBUS直近。ゲームパッド接続時の突入電流対策 |
| H1–H4 | 4 | M3ネジ・ナット・スペーサ | — | 穴φ3.2mm | 取付穴（PCB版のみ） |

⚠️ 電解コンの耐圧は**3S満充電12.6Vを超えること**（C1は25V品）。極性に注意。
C1〜C4は回路図上は電源ラベルで繋いでいるだけなので、**PCBでは必ず対象の直近に配置**すること

#### F1 ヒューズホルダの選択肢（2026-11-03 にデータシートで確認）

| 方式 | 秋月 | 足のピッチ・太さ | PCB版 | ユニバーサル基板版 |
|---|---|---|---|---|
| ミニ平型（基板図のフットプリント） | `118222` ¥480＋ヒューズ | φ1.78mm・9.92×3.4mm | ◎ そのまま | ✗ 穴に入らない |
| ガラス管ミゼット用クリップ **2個で1組** | `110521` ×**2** ＋ `107130`(5.2×20mm 2A) | φ1.7mm・足間6.7mm | △ フットプリント別途 | ✗ 穴に入らない |
| **配線用（インライン）** | — | 線のまま | — | ◎ **手組みはこれ** |

ユニバーサル基板の穴はφ約1mmなので、**基板取付品はどちらも挿さらない**（ピッチも
2.54mmの倍数でない）。手組みでは配線用ホルダを LiPo+ の線に割り込ませる
（[`docs/perfboard.html`](../docs/perfboard.html) の「部品ごとの注意」参照）。
ミニ平型のヒューズ本体は**カー用品店の自動車用ミニ平型2A**が入手しやすい。

（離して置くと効果がない）。

### ユニバーサル基板で組む場合の追加品

| 買うもの | 秋月 | 備考 |
|---|---|---|
| ユニバーサル基板 | `113156` | 両面スルーホール 8cm×12cm。必要な穴数は [`docs/perfboard.html`](../docs/perfboard.html) 参照。7cm×9cm（`113155`）はジャストサイズ。⚠️ **カタログ寸法と穴数は別物**で、秋月もサンハヤトも穴数を公表していない（95×72mmで30×25穴の製品が実在する）ので、サイズだけで選ばないこと |
| ピンソケット **1×20** を**2本** | `103077` ×2 | U1を抜き差しできるように（書込みのたびに外す）。⚠️ **2×20品は使えない** — Picoの2列は17.78mm(7穴)離れているので、2.54mm間隔の2列品では入らない |
| 配線用ヒューズホルダ＋2Aヒューズ | — | F1。基板取付品は穴に入らないので手組みはこちら（上記「F1 ヒューズホルダの選択肢」）。カー用品店／Amazonのミニ平型インラインホルダが手早い |
| 配線材（信号） | `109583` | ポリウレタン銅線 2UEW 0.29mm 20m。**28区間のうち18区間が被覆必須**で、その大半がこれ（[`docs/perfboard.html`](../docs/perfboard.html)「配線リスト」の「線」列） |
| 配線材（裸線） | — | **すずメッキ線 φ0.6mm**。GND母線6本と、配線5区間。⚠️ **母線は抵抗の切った足では足りない** — Cは23穴=58mm、Fは24穴ある |
| 配線材（電源） | — | **AWG24程度の被覆線**。5区間（VBAT 4本とヒューズ前のLiPo+） |

**秋月ぶんの概算は約¥1,430**（2026-10-27時点・Pico/Nano TX/ゲームパッド/LiPoを除く）。
抵抗が100本袋単位なので、その¥400が効いている。

上表の J1〜J4 は、手組みでは2.54mmピンヘッダで代用してもよい（J1だけは逆挿し対策で
キー付きコネクタを推奨）。J2とF1は足のピッチが2.54mmの倍数でないので、どちらにせよリード線になる。

## 再生成について

`tools/gen_sch.py` が KiCad 標準ライブラリからシンボルを取り出して
`recorder.kicad_sch` を生成する（配線はネットラベル方式）。

```bash
cd hardware/tools && python3 gen_sch.py ../recorder.kicad_sch
```

⚠️ **再生成すると KiCad の GUI で加えた編集は失われる。** 一度 KiCad で
編集を始めたら、このスクリプトは「どう作ったかの記録」として扱うこと。

## 設計レビューで挙がった注意点（2026-08-27）

回路図を一通り見直して出た項目。**対策済み**と**運用/レイアウトで対応**に分かれる。

### 対策済み（部品を追加した）

| 想定する故障 | 対策 |
|---|---|
| LiPoショート → 発火 | **F1** ヒューズ（LiPo+主線） |
| TX送信時の電圧ドロップ | **C1/C2**（VBATレール） |
| ゲームパッド接続時の突入電流 | **C3/C4**（5Vレール） |
| Buck短絡故障で12Vが5Vへ／活線挿抜サージ | **D6** TVS |
| J1逆挿しで13VがGP1直撃 | **R7** 1kΩ（GP0側は既存のR6 680Ω） |

### ⚠️ 部品では解決できない・運用で守る項目

- **J3(LiPo)の逆接続**。回路的な逆接続保護は入れていない。ただし標準的なLiPoコネクタ
  （XT30/XT60, Deans, JST-RCY, PH2.0/BT2.0 等）はすべて極性キー付きで、**差し込む時点で
  逆にはならない**。残るリスクは**基板側の実装ミス**（コネクタを逆向きにハンダ付けする、
  ピグテールの赤黒を逆に配線する）のみ。
  - 対策: **初回通電前にテスターでJ3の極性を確認**する。ここだけは目視ではなく実測。
  - 極性キーのないもの（ネジ端子・素のピンヘッダ）は使わない。
- **J1(Nano TX)の逆挿し**。3ピンで、逆に挿すとVBAT(最大13V)がCRSF線に乗る。
  R6/R7で電流は制限されるがGPIOには良くない。**キー付きコネクタにして、
  シルクに向きを大きく印刷**すること。
- **D6はPicoの延命を保証しない**。TVSのクランプ電圧(P6KE6.8CAで約10.5V)はPicoの絶対最大定格
  5.5Vより高いので、Buck短絡時にPicoは壊れる可能性が高い。D6の役目は
  「12Vが載り続ける状態を断ってヒューズを飛ばす」こと。
- **F1の2Aは暫定値**。実消費電流を測ってから決めること（測り方は下記）。
  過大だと保護にならず、過小だと送信時に飛ぶ。
- **LEDの電流は約13mA**（赤, 100Ω）で、RP2040のドライブ設定(既定4mA/最大12mA)を
  わずかに超える。パッドの電圧が垂れて自己制限されるため実用上は問題なく、
  ブレッドボードでも動作しているが、気になるなら150Ωへ。

### 実測が必要な項目（レイアウト前に確定させる）

| 項目 | 理由 |
|---|---|
| ~~送信側LiPoのセル数~~ | **決着（2026-10-27）: 3S**。2Sは放電末期に7VでNano TXの下限に触れる。満充電12.6Vも上限13Vの内側で、ブレッドボードで使ってきた12V電源装置とほぼ同じ条件になる |
| **LiPo側コネクタの型** | J3のフットプリント選定に必要。3Sパックを買う時に決まる（XT30想定）。手持ちパックに合わせるかは運用の判断で、電気的には極性キー付きなら何でもよい |
| **降圧モジュールの実寸・ピッチ** | 同型番でも製品差がある。ノギスで実測 |
| **地上側の消費電流** | F1のヒューズ定格を決めるため（下記） |

#### 消費電流の測り方 → ヒューズ定格

> ⚠️ **「Arm時」で測るのは誤り**。Armで増えるのは*機体側*のモーター電流で、機体の
> バッテリーから出ている。F1が守るのは**地上側（Pico＋Nano TX）**で、こちらはArm状態に
> 関係なく常時500Hzで送信しているため電流はほぼ一定。

支配的なのは **Nano TXの送信出力設定**（25mW〜1000mW）。次いでゲームパッドの消費とLED。
なので測るのは「**実際に使う設定での最大**」。

- **一番簡単**: ブレッドボード検証で使っている**安定化電源の電流表示を読む**。
  回路を切らずに済む。12Vを入れ、機体とリンクさせた状態で読む。
- **テスターの場合**: 電流モード（**10Aジャック**。mAジャックはテスター内蔵ヒューズが飛ぶ）で
  **LiPo+の線に直列**に入れる。まさにF1が入る位置。

測る条件: ①TXのみ ②ゲームパッド接続＋LED点灯 ③**TX出力を実際に使う最大**に設定。

定格は測定した最大の **1.5〜2倍**を標準値から選ぶ。**遅動(スローブロー)を選ぶこと** —
Buck入力コンデンサへの突入電流で、速断型だと投入のたびに飛ぶ恐れがある。

テスターもPSUも平均値表示だが、**ヒューズは熱で切れるので瞬間のピークでは飛ばない**。
平均値＋余裕で選べばよい。

> ⚠️ **電源装置が繋がっている今のうちに測る**。LiPoに移ってからだとテスターを直列に
> 入れる手間が増える。1回の測定で**ヒューズ定格とパック容量（電流×飛行時間×余裕）**が
> 同時に決まる。

#### 電源装置からLiPoに移る時が、F1が必要になる瞬間
電圧は3S（満充電12.6V）で12V電源装置とほぼ同じだが、**電流の出方が違う**。

- **電流制限が無くなる**。電源装置には制限があるので、配線ミスでショートしても頭打ちに
  なって守られていた。LiPoは内部抵抗が低く**数十A出る**。F1が「あった方がいい部品」から
  **必須部品**に変わるのはこの切り替えのタイミングで、それ以前のブレッドボード検証で
  問題が出ていなかったことは根拠にならない。
- **突入電流が大きくなる**。Buck入力コンデンサを充電する瞬間の電流がPSUより大きく出る。
  これが上記「遅動を選ぶこと」の理由。

### PCBレイアウト時に効く項目

- **裏面はGNDベタ**にする（スター結線を線で再現しない方が良い。詳細はCLAUDE.md参照）。
- **C1/C2はJ1の足元、C3/C4はU1のVBUSピンの足元**に置く。離すと効果が消える。
- **VBAT/+5V/GNDは太いトラック**（`recorder.kicad_pro` の `Power` ネットクラス 0.8mm）。
- **テストポイントを置く**: +5V / VBAT / GND / CRSF。デバッグが楽になる。
- **U1のUSB端子は基板端へ**。ゲームパッドのケーブルが挿さる向きに。
- **取り付け穴**を忘れない。

## 発注前チェック（必須）

### ⚠️ 実測で確定させる項目（部品が手元に戻ったら）

| 項目 | なぜ必要か |
|---|---|
| ~~降圧モジュール~~ | **対応済み**。購入品 MP1584EN 用のフットプリントを作成（下記） |
| **LiPoコネクタ** | J3は**ピグテールを直付けするパッド**にしてある。送信側は3S（XT30想定）。XT30等をコネクタで付けたい場合はJ3を差し替え |
| **ヒューズ定格** | F1はミニ平型ヒューズホルダ。定格は実測して決める（本文の測り方参照） |
| **SW1/SW2 の内部結線** | ⚠️ 下記。発注前にテスターで確かめる |

#### ⚠️ SW1/SW2 は「どの2本が内部で繋がっているか」を発注前に実測する

フットプリント `SW_PUSH_6mm` は **6.5mm離れた2本が同一端子**（pin1=(0,0)と(6.5,0)、
pin2=(0,4.5)と(6.5,4.5)）という前提で、PCBはその組を銅箔で繋いでいる。
**実物が逆（4.5mm側が同一端子）だと、挿した瞬間に2端子が短絡して「常時押されている」基板になる。**
フットプリントが6.5×4.5mmの長方形なので90°回しても逃げられない。

買ったスイッチの4本をテスターで当たり、**6.5mm離れた2本が常時導通**していることを
確認してから発注する。逆だった場合は `tools/gen_sch.py` のフットプリント指定を
`SW_PUSH_6mm_H5mm` 系の合うものに差し替えて再生成する。

> 手組み（ユニバーサル基板）では**対角の2本を使うので、どちらの向きでも問題にならない**。
> これが効くのはPCB版だけ。

### 手順

1. **`pcb-fab.pdf` を1:1で印刷し、実物の部品を載せて合わせる。**
   フットプリント違いは基板を1枚無駄にする最大の原因。**特にJ2**（寸法は商品写真からの
   画像解析であり、ノギス実測ではない）。8つの穴が実物と合うかを最優先で確認すること。
2. KiCadで **3Dビュー**を開き、部品の干渉とコネクタの向きを確認。
3. **DRCを製造業者の規格に合わせて再実行**（`recorder.kicad_pro` には
   最小クリアランス0.2mm / 最小線幅0.2mm を設定済み。JLCPCB等の標準で通る値）。
4. ガーバー出力:
   ```bash
   kicad-cli pcb export gerbers --output gerber/ hardware/recorder.kicad_pcb
   kicad-cli pcb export drill   --output gerber/ hardware/recorder.kicad_pcb
   ```

### 組み立て時の注意

- **J3の極性は初回通電前にテスターで実測**（コネクタは逆挿しできないが、実装ミスは起こる）。
- **電解コン(C1/C3)とLED(D1-D5)、TVS(D6)は極性あり**。シルクの向きに従う。
- **Picoの向き**: フットプリントのシルクに `USB` と角の面取りで pin1 側を示してある。
- Picoはメスヘッダに載せる想定（書き込み時に外せるように）。

## J2: MP1584EN 降圧モジュールのフットプリント

購入品（22.3×16.8mm、4隅に2穴ずつの計8穴）に合わせて `recorder.pretty/MP1584EN_Module`
を自作した。**寸法は商品写真を画像解析して求めた実測値**:

| 項目 | 値 |
|---|---|
| 基板サイズ | 22.3 × 16.8 mm |
| 穴の左右位置 | 中心から ±9.45 mm（測定値 9.35 / 9.52 の中間） |
| 穴の上下位置 | 中心から ±6.70 / ±4.16 mm（ペア間隔 2.54mm） |
| 穴径 / パッド | 1.0 / 1.7 mm |

ピン配置（**部品面から見て**）:

```
   IN-  ┌──────────────┐  OUT-
        │  IN  ──→ OUT │
   IN+  └──────────────┘  OUT+
```

裏面シルクは `OUT-(左上) IN-(右上) OUT+(左下) IN+(右下)` で、裏返すと左右が
入れ替わるため上記になる。部品面の ⊖/⊕ 表記が出力側にあることとも一致する。
回路図シンボル(Conn_01x04)との対応は `1=IN+ 2=IN- 3=OUT+ 4=OUT-`。

> ⚠️ **ノギスでの実測はしていない。** 誤差は最大0.1mm程度と見積もられ、穴径1.0mmなら
> 吸収できるはずだが、**発注前に `pcb-fab.pdf` を1:1印刷して実物を載せ、8穴が合うことを
> 必ず確認すること**。ズレていれば `tools/gen_buck_fp.py` の PAD_X / PAD_Y_OUT を
> 直して再生成する。

## 基板の設計判断

- **GNDはスター結線ではなくベタ**。CLAUDE.mdの「LiPo−起点のスター結線」は
  細い電線で組む前提の話で、基板ではベタの方がインピーダンスが桁違いに低く確実。
- **コンデンサは対象の直近に配置**: C1/C2はJ1(Nano TX)の足元、C3/C4はPicoのVBUSピンの
  足元。回路図上は等価でも、効果はレイアウトで決まる。
- **電源は太線(0.8mm)**、信号は0.25mm。
- **+5Vは基板を縦断する長い配線**（降圧モジュール→Pico VBUS, 約65mm）だが、
  0.6Aで電圧降下は約20mVなので問題ない。電流の大きいVBAT側を短くする配置を優先した。
- **J2は右下に配置**。VBAT(大電流)を短く、+5Vを基板縦断にする方針に加え、
  モジュール本体(22.3×16.8mm)がPicoと取付穴のどちらとも干渉しない位置がここだった。
- **U1のUSB端子は基板端から約8mm内側**。Picoはヘッダで約8mm持ち上がるのでケーブルは
  基板をまたげるが、気になるなら基板上端を数mm削ってもよい。

## 再生成について

```bash
cd hardware/tools
python3 gen_sch.py ../recorder.kicad_sch                      # 回路図
kicad-cli sch export netlist --format kicadsexpr -o net.net ../recorder.kicad_sch
python3 gen_pcb.py net.net ../recorder.kicad_sch ../recorder.kicad_pcb   # 基板
/Applications/KiCad/KiCad.app/Contents/Frameworks/Python.framework/Versions/3.9/bin/python3 \
    fill_zones.py ../recorder.kicad_pcb                       # ゾーン塗りつぶし
python3 gen_perf.py net.net ../../docs/perfboard.html         # ユニバーサル基板版
```

⚠️ `docs/perfboard.html` は `gen_perf.py` の出力。**HTMLを直接編集しても次の再生成で消える**ので、
直すときは `gen_perf.py` を直してから再生成すること。

⚠️ **再生成するとKiCadのGUIで加えた編集は失われる。** 一度GUIで編集を始めたら、
これらのスクリプトは「どう作ったかの記録」として扱うこと。

※ `kicad-cli` にはゾーンを塗る機能が無いため、塗りつぶしだけKiCad同梱のPython
(`pcbnew`)を使っている。塗らないとDRCがGNDを未配線と報告する。

Parts:
C1: 470uF/25V; CP_Radial_D10.0mm_P5.00mm
C2, C4: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 100uF/16V; CP_Radial_D6.3mm_P2.50mm
D1: Red; LED_D3.0mm
D2: Green; LED_D3.0mm
D3: Blue; LED_D3.0mm
D4, D5: LED; LED_D3.0mm
D6: P6KE6.8CA; D_DO-15_P10.16mm_Horizontal
F1: 2A; Fuseholder_Blade_Mini_Keystone_3568
J1: Nano TX V2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: Buck MP1584E; MP1584EN_Module
J3: LiPo 3S / PSU; SolderWire-0.75sqmm_1x02_P7mm_D1.25mm_OD3.5mm
J4: USB-Serial; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R3, R4, R5: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 680R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2: SW_Push; SW_PUSH_6mm
SW3: SW_SPST; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
U1: Raspberry Pi Pico; RPi_Pico_Headers

Connections:
+5V: C3.1, C4.1, D6.2 (A2), J2.3, U1.40 (VBUS)
/BTN_INPUT: SW2.1, U1.9 (GPIO6)
/BTN_MODE: SW1.1, U1.4 (GPIO2)
/CRSF_BUS: J1.1, R6.2, R7.1
/CRSF_TX: R6.1, U1.1 (GPIO0)
/DBG_RX: J4.2, U1.7 (GPIO5)
/DBG_TX: J4.1, U1.6 (GPIO4)
/LED_GENERIC: R4.1, U1.17 (GPIO13)
/LED_LITERADIO: R5.1, U1.19 (GPIO14)
/LED_PLAY: R2.1, U1.15 (GPIO11)
/LED_REC: R1.1, U1.14 (GPIO10)
/LED_SIMPLE: R3.1, U1.16 (GPIO12)
/SW_ARM: SW3.1 (A), U1.5 (GPIO3)
/VBAT_7_13V: C1.1, C2.1, F1.1, J1.3, J2.1
GND: C1.2, C2.2, C3.2, C4.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (A1), J1.2, J2.2, J2.4, J3.2, J4.3, SW1.2, SW2.2, SW3.2 (B), U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.38 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: F1.2, J3.1
unnamed: R7.2, U1.2 (GPIO1)

Notes on the sheet:
USB(micro-B) = ゲームパッド接続
※VSYS給電はNG（USBポートに5Vが回らない）
LEDは5個とも100Ω（緑/青はVf≈3Vで330Ωでは暗い）
モード切替(GP2)
入力切替(GP6)
Armトグル(GP3)
スイッチは内部プルアップ使用のため外付け抵抗不要
Nano TX V2 (背面視 左から CRSF/GND/7-13V)
※半二重1本・反転UART 921600bps
IN+ / IN- / OUT+ / OUT-
⚠️ Picoに繋ぐ前にテスターで5.0Vへ調整
⚠️ Buck出力5VとLiPo+は絶対に接続しない
GNDはLiPo−起点のスター結線
C1/C2: Nano TX VBAT直近に置く（送信バーストの電圧ドロップ対策）
C3/C4: Pico VBUS直近に置く（ゲームパッド接続時の突入電流対策）
⚠️ 電解コンの耐圧は3S満充電12.6Vを超えること。極性に注意
D6: Buck短絡故障時に12Vが5Vへ出るのを断つ（ヒューズを飛ばす）
変換器RXD←DBG_TX / TXD→DBG_RX
921600bps（手持ちFTDIは115200指定で読める）

Board: 2 copper layers, 105.0 x 85.0 mm, 30 parts (0 on the bottom side), 22 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3

## Code that names these connections

File hardware/tools/gen_sch.py (part):

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place(PICO, 'U1', 'Raspberry Pi Pico', (PX, PY, 0))

# --- Pico 左側: 信号 ---
stub_label(PICO, (PX, PY, 0), '1',  'CRSF_TX')     # GP0
# GP1は保護抵抗を挟んでバスへ。GP0側の680Ωと違い直結だと、J1を逆挿しした際に
# VBAT(最大13V)が素通しでGPIOへ入る。1kΩなら故障電流を十数mAに抑えられる。
# 921600bpsに対し 1k×入力容量数pF = 数ns なので波形への影響は無視できる。
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r7l = pin_xy('Device:R', (gp1[0] - 12.7, gp1[1], 90), '1')
wire((gp1[0], gp1[1]), (r7r[0], r7r[1]))
wire((r7l[0], r7l[1]), (r7l[0] - 5.08, r7l[1]))
label('CRSF_BUS', (r7l[0] - 5.08, r7l[1]), 0, 'right')
stub_label(PICO, (PX, PY, 0), '4',  'BTN_MODE')    # GP2
stub_label(PICO, (PX, PY, 0), '5',  'SW_ARM')      # GP3
stub_label(PICO, (PX, PY, 0), '6',  'DBG_TX')      # GP4
stub_label(PICO, (PX, PY, 0), '7',  'DBG_RX')      # GP5
stub_label(PICO, (PX, PY, 0), '9',  'BTN_INPUT')   # GP6
stub_label(PICO, (PX, PY, 0), '14', 'LED_REC')     # GP10
stub_label(PICO, (PX, PY, 0), '15', 'LED_PLAY')    # GP11
stub_label(PICO, (PX, PY, 0), '16', 'LED_SIMPLE')  # GP12
stub_label(PICO, (PX, PY, 0), '17', 'LED_GENERIC') # GP13
stub_label(PICO, (PX, PY, 0), '19', 'LED_LITERADIO')# GP14

# --- Pico 電源 ---
vb = pin_xy(PICO, (PX, PY, 0), '40')               # VBUS (上)
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r6l = pin_xy('Device:R', (c1[0] - 20.32, c1[1], 90), '1')
r6r = pin_xy('Device:R', (c1[0] - 20.32, c1[1], 90), '2')
wire((r6l[0], r6l[1]), (r6l[0] - 5.08, r6l[1]))
label('CRSF_TX', (r6l[0] - 5.08, r6l[1]), 0, 'right')
# 半二重: RX(GP1)は抵抗より先のバス側に付く（参照図 63bit R63b と同じ）。
# 自分の送信エコーもRXに入るが、ファーム側の drain 処理で読み捨てている。
# T字接続を確実にするため、水平線を分岐点で2本に割って端点を一致させる。
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wire((r6r[0], r6r[1]), mid)
wire(mid, (c1[0], c1[1]))
wire(mid, (mid[0], mid[1] - 7.62))
label('CRSF_BUS', (mid[0], mid[1] - 7.62), 90, 'left')
junction(mid)
wire((c2[0], c2[1]), (c2[0] - 7.62, c2[1]))
power('power:GND', (c2[0] - 7.62, c2[1], 270))
wire((c3[0], c3[1]), (c3[0] - 7.62, c3[1]))
label('VBAT_7_13V', (c3[0] - 7.62, c3[1]), 0, 'right')
text_note('Nano TX V2 (背面視 左から CRSF/GND/7-13V)\n※半二重1本・反転UART 921600bps',
          (NX - 30, NY - 10), 1.27)

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f1b = pin_xy('Device:Fuse', (p1[0] - 15.24, p1[1], 90), '2')
wire((f1b[0], f1b[1]), (p1[0], p1[1]))
wire((f1a[0], f1a[1]), (f1a[0] - 5.08, f1a[1]))
label('VBAT_7_13V', (f1a[0] - 5.08, f1a[1]), 0, 'right')
wire((p2[0], p2[1]), (p2[0] - 7.62, p2[1]))
power('power:GND', (p2[0] - 7.62, p2[1], 270))
text_note('⚠️ Buck出力5VとLiPo+は絶対に接続しない\nGNDはLiPo−起点のスター結線',
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u2 = pin_xy('Connector_Generic:Conn_01x03', (UX, UY, 0), '2')
u3 = pin_xy('Connector_Generic:Conn_01x03', (UX, UY, 0), '3')
wire((u1[0], u1[1]), (u1[0] - 7.62, u1[1]))
label('DBG_TX', (u1[0] - 7.62, u1[1]), 0, 'right')
wire((u2[0], u2[1]), (u2[0] - 7.62, u2[1]))
label('DBG_RX', (u2[0] - 7.62, u2[1]), 0, 'right')
wire((u3[0], u3[1]), (u3[0] - 7.62, u3[1]))
power('power:GND', (u3[0] - 7.62, u3[1], 270))
text_note('変換器RXD←DBG_TX / TXD→DBG_RX\n921600bps（手持ちFTDIは115200指定で読める）',
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